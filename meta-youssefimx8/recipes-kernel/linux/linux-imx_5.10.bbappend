# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)
#
# SPDX-License-Identifier: MIT
#

LICENSE = "GPLv2"
KERNEL_SRC = "git://${BSPDIR}/../../youssefTest/linuxIMX8/kernel-source;protocol=file"
SRCBRANCH = "youssef_imx_8qxp"
SRCREV = "ee0621267bb220ed3d917f334de8c9d07b85b01c"
