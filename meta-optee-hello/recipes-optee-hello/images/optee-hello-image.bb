require recipes-fsl/images/imx-image-core.bb
IMAGE_INSTALL += "optee-hello"