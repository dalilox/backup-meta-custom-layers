#SUMMARY = "bitbake-layers recipe"
#DESCRIPTION = "Recipe created by bitbake-layers"
#LICENSE = "CLOSED"

#SRC_URI = "git://${BSPDIR}/../../youssefTest/linuxIMX8/meta-hellopatch;protocol=file;usehead=1"
#SRCBRANCH = "test"
#SRCREV = "44c2a496466548d7d90c55fd8913515d4e0f8c13"
